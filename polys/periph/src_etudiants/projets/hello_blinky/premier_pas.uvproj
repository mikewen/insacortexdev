# Keil uVision project premier_pas.uvproj, settings and files
target simulateur (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: premier_pas
  c flags: Optim=1
  c include: ..\..\sys;.
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group sys
    ../../sys/: STM32F10x.s
  group pilotes
    ../../pilotes/: stm_clock.c
    ./: stm_clock_config.h
  group appli
    ./: main.c
