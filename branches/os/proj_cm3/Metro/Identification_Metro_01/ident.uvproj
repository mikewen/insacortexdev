# Keil uVision project ident.uvproj, settings and files
target Simu (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ident
  c flags: Optim=1
  c include: ..\..\..\lib_cm3;..\Identification_Metro_01
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ./: STM32F10x.s STM32_Init.c STM32_Init.h STM32_Reg.h
  group Apps
    ./: Identification.c RTX_Conf_CM.c
    ../../../lib_cm3/: stm_metro_v1.c stm_clock.c
target Loco_Olymex (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: ident
  c flags: Optim=1
  c include: ..\..\..\lib_cm3;..\Identification_Metro_01
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
