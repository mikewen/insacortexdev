# Keil uVision project baguette.uvproj, settings and files
target Reel (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: baguette
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ./: STM32_Init.c STM32F10x.s
  group Apps
    ./: main.c font8.c ihm.c LCD_4bit.c led.c
