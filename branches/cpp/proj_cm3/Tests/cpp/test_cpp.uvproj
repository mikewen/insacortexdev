# Keil uVision project test_cpp.uvproj, settings and files
target Simu (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test_cpp
  group System
    ../../../system/: Startup_GCC.s STM32F10x_GCC.s
  group Drivers
    ../../../lib_cm3/cpp/: stm_usart.cpp stm_clock.cpp
  group Apps
    ./: main.cpp
