# Keil uVision project Usart_gcc.uvproj, settings and files
target simulateur (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Usart_gcc
  group boot
    ../../../system/: Startup_GCC.s STM32F10x_GCC.s
  group libs
    ../../../lib_cm3/: lib_usartx.c lib_usartx.h lib_printf.c lib_puts.c
  group src
    ./: test_usart.c
target reel (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Usart_gcc
