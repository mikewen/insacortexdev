# Keil uVision project test_nvic.uvproj, settings and files
target Sim (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test_nvic
  group System
    ../../../system/: Startup_GCC.s STM32F10x_GCC.s
  group Lib
    ../../../lib_cm3/: stm_nvic.c stm_nvic.h
  group Test
    ./: test.c
