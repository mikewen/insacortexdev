# Keil uVision project CDC_example.uvproj, settings and files
target Reel (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CDC_example
  AfterMake: "C:\Program Files\CodeSourcery\Sourcery G++ Lite\bin\arm-none-eabi-size.exe" release\*.elf
  group systeme
    ../../../system/: STM32F10x_GCC.s Startup_GCC.s
  group appli
    ./: main.c
  group lib_usb_generique
    ../../../lib_cm3/USB/generique/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group lib_usb_cdc
    ../../../lib_cm3/USB/specifique/CDC/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_cdc.c
  group drivers
    ../../../lib_cm3/: stm_clock.c
target Simu (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: CDC_example
  AfterMake: as above
