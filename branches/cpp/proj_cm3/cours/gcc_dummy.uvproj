# Keil uVision project gcc_dummy.uvproj, settings and files
target Simulateur (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: buffer_gcc
  group sys
    ../../system/: STM32F10x_GCC.s Startup_GCC.s
  group app
    ./: main_dummy.c waits.c
