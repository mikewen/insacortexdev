# Keil uVision project flash.uvproj, settings and files
target Simu (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test_flash
  AfterMake: "C:\Program Files\CodeSourcery\Sourcery G++ Lite\bin\arm-none-eabi-size.exe" objs\*.elf
  group System
    ../../../lib_cm3/: stm_clock.c
    ../../../system/: STM32F10x_GCC.s Startup_GCC.s
  group Appli
    ./: test.c
  group Drivers
    ../../../lib_cm3/: lib_flash.c
  group Autres
    ./: Linker_Script_GCC_flash.ld
target Reel (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: test_flash
  AfterMake: as above
