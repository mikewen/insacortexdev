# Keil uVision project baguette_asm.uvproj, settings and files
target Simulateur (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: baguette_asm
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group sys
    ../../../system/: STM32F10x.s
  group obj
    ../objs_lib_baguette/: lib_baguette.inc stm_clock.o stm_usartx.o lcd_4bit.o lib_baguette.o
  group app
    ../../../lib_user/: font8.c
    ./: main_p0_debug.s
target MCBSTM32 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: baguette_asm
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
