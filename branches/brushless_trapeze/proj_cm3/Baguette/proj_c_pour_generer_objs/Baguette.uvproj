# Keil uVision project Baguette.uvproj, settings and files
target Reel (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: baguette
  c flags: Optim=4
  c include: ..\..\..\system;..\..\..\lib_cm3;..\..\..\lib_user;..\proj_c_pour_generer_objs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ../../../system/: STM32F10x.s
  group Apps
    ./: main.c
    ../../../lib_user/: font8.c
  group Lib
    ../../../lib_cm3/: lib_baguette.c stm_clock.c stm_system.c stm_usartx.c LCD_4bit.c
    ./: stm_clock_config.h stm_usartx_config.h
target Simu (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: baguette
  c flags: Optim=4
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
