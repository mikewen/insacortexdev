# Keil uVision project gcc_buffer.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: buffer_gcc
  group Source Group 1
    ../../system/: Startup_GCC.s
    ./: buff_main.c waits.c helf_hash.c
    ../../lib_cm3/: stm_usartx.c stm_clock.c
    ../../minilib/syscalls_template/: syscalls.c
  group sys
    ../../lib_cm3/: stm_system.c
    ../../system/: STM32F10x_GCC.s
