# Keil uVision project libmini-ARMCC.uvproj, settings and files
target Sim (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mini
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group test
    ./: STM32F10x.s test.c syscalls.c
  group include
    ../include/: missing_defs.h syscalls.h
  group stdio
    ../stdio/: fgetc.c fgets.c fputc.c fputs.c getchar.c printf.c putchar.c scanf.c
  group stdlib
    ../stdlib/: abs.c assert.c atoi.c atol.c calloc.c div.c exit.c ldiv.c malloc.c mallocr.c rand.c strtol.c system.c valloc.c
  group ctype
    ../ctype/: isalnum.c isalpha.c isascii.c isblank.c iscntrl.c isdigit.c islower.c isprint.c ispunct.c isspace.c isupper.c isxdigit.c toascii.c tolower.c toupper.c
  group string
    ../string/: bcmp.c bcopy.c bzero.c index.c memccpy.c memchr.c memcmp.c memcpy.c memmem.c memmove.c mempcpy.c memset.c rindex.c strcat.c strchr.c strcmp.c strcoll.c strcpy.c strcspn.c strdup.c strerror.c strlcat.c strlcpy.c strlen.c strlwr.c strncat.c strncmp.c strncpy.c strndup.c strnlen.c strrchr.c strsep.c strspn.c strstr.c strtok.c strupr.c
