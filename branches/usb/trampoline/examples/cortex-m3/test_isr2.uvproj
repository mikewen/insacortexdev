# Keil uVision project test_isr2.uvproj, settings and files
target Simulé (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Projet_GCC
  group Systeme
    ../../../system/: Startup_GCC.s STM32F10x_GCC.s
  group os
    ../../os/: tpl_os_action.c tpl_os_alarm_kernel.c tpl_os_alarm.c tpl_os_error.c tpl_os_event.c tpl_os_it_kernel.c tpl_os_it.c tpl_os_kernel.c tpl_os_rez_kernel.c tpl_os_rez.c tpl_os_task.c tpl_os.c tpl_os_timeobj_kernel.c tpl_os_dispatch_table.c tpl_os_event_kernel.c tpl_os_task_kernel.c
  group os_machine
    ../../machines/cortex-m3/: tpl_machine_cm3.c
  group Appli
    ./: test_isr2_main.c periphs.c
    ./test_isr2/: tpl_os_generated_configuration.c
  group Include
    ../../system/: STM32_Init.h STM32_Reg.h
  group templates
    ./: test_isr2.oil
    ../../goil/templates/code/cortex-m3/: isr_specific.tpl each_isr_specific.tpl
target Reel (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Projet_GCC
  AfterMake: "C:\Program Files\CodeSourcery\Sourcery G++ Lite\bin\arm-none-eabi-size.exe" Projet_GCC.elf
