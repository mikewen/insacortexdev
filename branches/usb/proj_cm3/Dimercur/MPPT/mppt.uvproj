# Keil uVision project mppt.uvproj, settings and files
target Simu (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mppt
  AfterMake: "C:\Program Files\CodeSourcery\Sourcery G++ Lite\bin\arm-none-eabi-size.exe" objs\*.elf
  group System
    ../../system/: Startup_GCC.s STM32F10x_GCC.s
    ../../lib_cm3/: stm_usartx.c stm_clock.c
  group Apps
    ./: adc.c mppt.c pwm.c
target Reel (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: audio
  AfterMake: as above
