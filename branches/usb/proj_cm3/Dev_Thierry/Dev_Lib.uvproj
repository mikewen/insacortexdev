# Keil uVision project Dev_Lib.uvproj, settings and files
target Simule (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Dev_Lib
  c flags: Optim=1
  c include: ..\..\lib_Thierry;..\..\lib_cm3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Sys
    ../../system/: STM32F10x.s
  group Lib
    ../../lib_Thierry/: PWM.c ADC.c NVIC_SysTick.c Port_IO.c
  group Source
    ./: Principal_4.c
target Carte (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Dev_Lib
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
