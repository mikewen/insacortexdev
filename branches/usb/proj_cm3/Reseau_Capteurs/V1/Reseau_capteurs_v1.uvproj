# Keil uVision project Reseau_capteurs_v1.uvproj, settings and files
target Simu (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Reseau_capteurs_v1
  c flags: Optim=1
  c define: _IS_SLAVE_ _LCD_DEBUG_
  c include: .\drivers;.\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ./: STM32F10x.s
    ./system/: STM32_Init.c
  group Appli
    ./: main.c
  group Drivers
    ./drivers/: adc.c at.c gpio.c LCD_4bit.c rs606.c time.c uart.c
target Reel_Master (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Reseau_capteurs_v1
  c flags: Optim=1
  c define: _IS_MASTER_
  c include: .\drivers;.\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Reel_Slave (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Reseau_capteurs_v1
  c flags: Optim=1
  c define: _IS_SLAVE_
  c include: .\drivers;.\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
