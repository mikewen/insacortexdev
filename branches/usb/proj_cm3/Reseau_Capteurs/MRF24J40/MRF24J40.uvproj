# Keil uVision project MRF24J40.uvproj, settings and files
target Simu (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MRF24J40
  AfterMake: "C:\Program Files\CodeSourcery\Sourcery G++ Lite\bin\arm-none-eabi-size.exe" objs\*.elf
  group System
    ../../../system/: STM32F10x_GCC.s Startup_GCC.s
  group Phy/Mac
    ./MRF24J40/: MRF24J40_mac.c MRF24J40_phy.c
  group Apps
    ./: syscalls.c Appli.c
  group Drivers
    ../../../lib_cm3/: LCD_4bit.c stm_clock.c stm_usartx.c
