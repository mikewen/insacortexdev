# Keil uVision project firstAVR.uvproj, settings and files
target simulateur (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: firstAVR
  group os
    ../../os/: tpl_os_action.c tpl_os_alarm_kernel.c tpl_os_alarm.c tpl_os_dispatch_table.c tpl_os_error.c tpl_os_event_kernel.c tpl_os_event.c tpl_os_it_kernel.c tpl_os_it.c tpl_os_kernel.c tpl_os_rez_kernel.c tpl_os_rez.c tpl_os_task_kernel.c tpl_os_task.c tpl_os_timeobj_kernel.c tpl_os.c
    ../../com/: tpl_com_app_copy.c tpl_com_errorhook.c tpl_com_external_com.c tpl_com_filtering.c tpl_com_filters.c tpl_com_internal_com.c tpl_com_message_management.c tpl_com_notification.c tpl_com_queue.c
    ../../debug/: tpl_debug.c
    ../../machines/cortex-m3/: tpl_machine_cm3.c
  group appli
    ./firstAVR/: tpl_os_generated_configuration.c
    ./: firstAVR_main.c
  group system
    ./: STM32_Init.c STM32F10x.s
