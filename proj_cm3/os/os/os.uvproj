# Keil uVision project os.uvproj, settings and files
target Simulé (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: OS
  AfterMake: "C:\Program Files\CodeSourcery\Sourcery G++ Lite\bin\arm-none-eabi-size.exe" ./obj/*.elf
  group Systeme
    ../../../system/: STM32F10x_GCC.s Linker_Script_GCC.ld STM32_Init.c Startup_GCC.s
  group Appli
    ./: main.c
  group Include
    ../../../system/: STM32_Init.h STM32_Reg.h
  group OS
    ../../../os/: os.c os_entries.S os.h os_call.h
  group toto
    ./: toto.S
target Reel (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: OS
  AfterMake: "C:\Program Files\CodeSourcery\bin\arm-none-eabi-size.exe" obj\*.elf
