# Keil uVision project filtre.uvproj, settings and files
target Simu (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: filtre
  AfterMake: "C:\Program Files\CodeSourcery\Sourcery G++ Lite\bin\arm-none-eabi-size.exe" objs\*.elf
  group Startup
    ../../system/: STM32F10x_GCC.s Startup_GCC.s
  group Drivers
    ./: pwm.c adc.c
    ../../lib_cm3/: stm_clock.c
  group Appli
    ./: filtre.c
  group Divers
    ./: Filtre.ini
target Reel (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: filtre
  AfterMake: as above
