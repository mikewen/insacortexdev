# Keil uVision project baguette.uvproj, settings and files
target Reel (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: baguette
  c flags: Optim=1
  c include: ..\..\lib_user;..\..\lib_cm3;..\Baguette;..\..\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ./: STM32F10x.s
  group Apps
    ./: main.c font8.c
  group Lib
    ../../lib_user/: lib_baguette.c lib_baguette.h lib_baguette.inc
    ../../lib_cm3/: stm_clock.c stm_usartx.c LCD_4bit.c LCD.h stm_system.h stm_regs.h
    ./: stm_clock_config.h stm_usartx_config.h
target Simu (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: baguette
  c flags: Optim=1
  c include: ..\..\lib_cm3;..\..\lib_user;..\Baguette;..\..\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
