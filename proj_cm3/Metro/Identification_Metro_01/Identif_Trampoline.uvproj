# Keil uVision project Identif_Trampoline.uvproj, settings and files
target Simulateur (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Projet_No_CAN
  AfterMake: "C:\Program Files\CodeSourcery\Sourcery G++ Lite\bin\arm-none-eabi-size.exe" objs/*.ELF
  group sys
    ../../../system/: STM32F10x_GCC.s Startup_GCC.s
  group os
    ../../../trampoline/os/: tpl_os.c tpl_os_action.c tpl_os_alarm.c tpl_os_alarm_kernel.c tpl_os_dispatch_table.c tpl_os_error.c tpl_os_event.c tpl_os_event_kernel.c tpl_os_it.c tpl_os_it_kernel.c tpl_os_kernel.c tpl_os_rez.c tpl_os_rez_kernel.c tpl_os_task.c tpl_os_task_kernel.c tpl_os_timeobj_kernel.c tpl_trace.c
  group os_machine
    ../../../trampoline/machines/cortex-m3/: tpl_machine_cm3.c
  group lib
    ../../../lib_cm3/: stm_clock.c stm_metro_v1.c cm3_traps.c stm_usartx.c
    ../../../minilib/syscalls_template/: syscalls.c
  group appli
    ./: Identif_Trampoline.oil Identification_Trampo.c
    ./Identif_Trampoline/: tpl_os_generated_configuration.c
target Locolymex (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Projet_No_CAN
  AfterMake: "C:\Program Files\CodeSourcery\Sourcery G++ Lite\bin\arm-none-eabi-size.exe" objs
target MCBSTM32 (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Projet_No_CAN
