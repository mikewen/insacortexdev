# Keil uVision project adc_dma.uvproj, settings and files
target simulateur (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: adc_dma
  group system
    ../../../system/: Startup_GCC.s STM32F10x_GCC.s
  group lib
    ../../../lib_cm3/: stm_clock.c stm_timx.c cm3_traps.c stm_system.c stm_usartx.c
  group appli
    ./: main.c syscalls.c
  group configs
    ./: stm_clock_config.h stm_usartx_config.h cm3_traps_config.h stm_timx_config.h
