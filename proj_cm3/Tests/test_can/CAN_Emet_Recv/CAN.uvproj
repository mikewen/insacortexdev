# Keil uVision project CAN.uvproj, settings and files
target Simulator_Emetteru (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CanDemo
  c flags: Optim=1
  c define: EMMETEUR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ./: STM32F10x.s
  group Initialisation
    ./: STM32_Init.c
  group Source
    ./: LCD_4bit.c CAN.c CanDemo.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32_Emmeteur (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: CanDemo
  c flags: Optim=1
  c define: EMMETEUR,RECEPTEUR
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Simulator_Recpteur (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: CanDemo
  c flags: Optim=1
  c define: RECEPTEUR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MCBSTM32_Recepteur (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: CanDemo
  c flags: Optim=1
  c define: RECEPTEUR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target OLIMEX Emmeteur (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: CanDemo
  c flags: Optim=1
  c define: EMMETEUR,RECEPTEUR,NO_LCD
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target OLIMEX_Emmeteur_simu (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: CanDemo
  c flags: Optim=1
  c define: EMMETEUR,RECEPTEUR,NO_LCD
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
