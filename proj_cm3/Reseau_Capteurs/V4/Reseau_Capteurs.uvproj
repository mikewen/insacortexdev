# Keil uVision project Reseau_Capteurs.uvproj, settings and files
target Simu (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Reseau_Capteurs
  c flags: Optim=1
  c define: _LCD_DEBUG_
  c include: .\drivers;.\system;..\..\..\minilib\include;..\..\..\lib_cm3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ./system/: STM32_Init.c STM32F10x.s
    ./drivers/: LCD_4bit.c
  group App
    ./: main.c syscalls.c
  group Drivers
    ./drivers/: adc.c gpio.c rs606.c time.c uart.c
  group Lib
    ../../../minilib/lib/arm-cm3/ARMCC/: mini.lib
target Reel (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Reseau_Capteurs
  c flags: Optim=1
  c include: .\drivers;.\system;..\..\..\minilib\include;..\..\..\lib_cm3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
