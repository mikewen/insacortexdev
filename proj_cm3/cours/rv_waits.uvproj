# Keil uVision project rv_waits.uvproj, settings and files
target simulateur (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rv_dummy
  c flags: Optim=4 wLevel=2
  memory RVCT1: ROM 0x8010000 size 0x10000
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group sys
    ../../system/: STM32F10x.s
  group app
    ./: waits.c main_dummy.c dummy_asm.s
