# Keil uVision project rv_buffer.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: buffer
  c flags: Optim=3 wLevel=2
  c include: .;..\..\lib_cm3;..\..\minilib\include;..\..\system
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: STM32F10x.s buff_main.c waits.c dummy_asm.s helf_hash.c
    ../../lib_cm3/: stm_clock.c stm_usartx.c
