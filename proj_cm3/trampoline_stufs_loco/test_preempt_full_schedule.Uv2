### uVision2 Project, (C) Keil Software
### Do not modify !

Target (Simulé), 0x0003 // Tools: 'ARM-GNU'
Target (Reel), 0x0003 // Tools: 'ARM-GNU'
Target (lkjh), 0x0003 // Tools: 'ARM-GNU'

Group (Systeme)
Group (os)
Group (os_machines)
Group (os_com)
Group (os_debug)
Group (Lib)
Group (Appli)
Group (Include)

File 1,1,<../../system/STM32_Init.c><STM32_Init.c>
File 1,2,<../../system/STM32F10x_GCC.s><STM32F10x_GCC.s>
File 1,2,<../../system/Startup_GCC.s><Startup_GCC.s>
File 2,1,<../../trampoline/os/tpl_os.c><tpl_os.c>
File 2,1,<../../trampoline/os/tpl_os_action.c><tpl_os_action.c>
File 2,1,<../../trampoline/os/tpl_os_alarm.c><tpl_os_alarm.c>
File 2,1,<../../trampoline/os/tpl_os_alarm_kernel.c><tpl_os_alarm_kernel.c>
File 2,1,<../../trampoline/os/tpl_os_dispatch_table.c><tpl_os_dispatch_table.c>
File 2,1,<../../trampoline/os/tpl_os_error.c><tpl_os_error.c>
File 2,1,<../../trampoline/os/tpl_os_event.c><tpl_os_event.c>
File 2,1,<../../trampoline/os/tpl_os_event_kernel.c><tpl_os_event_kernel.c>
File 2,1,<../../trampoline/os/tpl_os_it.c><tpl_os_it.c>
File 2,1,<../../trampoline/os/tpl_os_it_kernel.c><tpl_os_it_kernel.c>
File 2,1,<../../trampoline/os/tpl_os_kernel.c><tpl_os_kernel.c>
File 2,1,<../../trampoline/os/tpl_os_rez.c><tpl_os_rez.c>
File 2,1,<../../trampoline/os/tpl_os_rez_kernel.c><tpl_os_rez_kernel.c>
File 2,1,<../../trampoline/os/tpl_os_task.c><tpl_os_task.c>
File 2,1,<../../trampoline/os/tpl_os_task_kernel.c><tpl_os_task_kernel.c>
File 2,1,<../../trampoline/os/tpl_os_timeobj_kernel.c><tpl_os_timeobj_kernel.c>
File 3,1,<../../trampoline/machines/cortex-m3/tpl_machine_cm3.c><tpl_machine_cm3.c>
File 4,1,<../../trampoline/com/tpl_com_queue.c><tpl_com_queue.c>
File 4,1,<../../trampoline/com/tpl_com_app_copy.c><tpl_com_app_copy.c>
File 4,1,<../../trampoline/com/tpl_com_errorhook.c><tpl_com_errorhook.c>
File 4,1,<../../trampoline/com/tpl_com_external_com.c><tpl_com_external_com.c>
File 4,1,<../../trampoline/com/tpl_com_filtering.c><tpl_com_filtering.c>
File 4,1,<../../trampoline/com/tpl_com_filters.c><tpl_com_filters.c>
File 4,1,<../../trampoline/com/tpl_com_internal_com.c><tpl_com_internal_com.c>
File 4,1,<../../trampoline/com/tpl_com_message_management.c><tpl_com_message_management.c>
File 4,1,<../../trampoline/com/tpl_com_notification.c><tpl_com_notification.c>
File 5,1,<../../trampoline/debug/tpl_debug.c><tpl_debug.c>
File 6,1,<../../lib_user/uart.c><uart.c>
File 6,1,<../../lib_user/LCD_4bit.c><LCD_4bit.c>
File 6,1,<../../lib_user/lib_trajectoire_2009a.c><lib_trajectoire_2009a.c>
File 6,1,<../../lib_user/led.c><led.c>
File 6,1,<../../lib_cm3/Metro_Librairie_Version2009d.c><Metro_Librairie_Version2009d.c>
File 7,1,<.\test_preempt_full_schedule/tpl_os_generated_configuration.c><tpl_os_generated_configuration.c>
File 7,1,<.\test_preempt_full_schedule_main.c><test_preempt_full_schedule_main.c>
File 8,5,<..\..\lib_user\lib_trajectoire_2009a.h><lib_trajectoire_2009a.h>
File 8,5,<..\..\lib_user\lib_autom_2008a.h><lib_autom_2008a.h>
File 8,5,<..\..\lib_user\LCD.h><LCD.h>
File 8,5,<..\..\lib_user\uart.h><uart.h>
File 8,5,<..\..\lib_cm3\Metro_Librairie_Version2009d.h><Metro_Librairie_Version2009d.h>


Options 1,0,0  // Target 'Simulé'
 Device (STM32F103RB)
 Vendor (STMicroelectronics)
 Cpu (IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3"))
 FlashUt ()
 StupF ("STARTUP\ST\STM32F10x.s" ("STM32 Startup Code"))
 FlashDR (UL2CM3(-O14 -S0 -C0 -N00("ARM Cortex-M3") -D00(1BA00477) -L00(4) -FO7 -FD20000000 -FC800 -FN1 -FF0STM32F10x_128 -FS08000000 -FL020000))
 DevID (4231)
 Rgf (stm32f10x_lib.h)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg ()
 OrgReg (ST\STM32F10x\)
 TgStat=16
 OutDir (.\)
 OutName (test_preempt_full_schedule)
 GenApp=1
 GenLib=0
 GenHex=0
 Debug=1
 Browse=0
 LstDir (.\)
 HexSel=1
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 CrunUsr 0 0 <>
 CrunUsr 1 0 <>
 SVCSID <>
 GLFLAGS=1790
 GCPUTYP ("Cortex-M3")
 TFlagsA { 0,12,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCMARM { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCMARAM { 0,0,0,0,32,0,80,0,0 }
 OCMAROM { 1,0,0,0,8,0,0,2,0 }
 OCMXRAM { 0,0,0,0,0,0,0,0,0 }
 OCMIRAM2 { 0,0,0,0,0,0,0,0,0 }
 OCMIROM2 { 0,0,0,0,0,0,0,0,0 }
 ACCFLG { 65,0,32,16,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ACMISC ()
 ACDEFN ()
 ACUDEF ()
 ACINCD (..\..\trampoline\com;..\..\trampoline\os;..\..\trampoline\debug;..\..\trampoline\machines\cortex-m3;..\..\lib_user;.\test_preempt_full_schedule)
 AASFLG { 4,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 AAMISC ()
 AADEFN ()
 AAUDEF ()
 AAINCD ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 ALDFLAG { 21,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ALDTADR ()
 ALDDADR ()
 ALDBSSR ()
 ALDICLB ()
 ALDICDR ()
 ALDMISC ()
 ALDSCAT (..\..\system\Linker_Script_GCC.ld -g)
  OPTDL (SARMCM3.DLL)()(DARMSTM.DLL)(-pSTM32F103RB)(SARMCM3.DLL)()(TARMSTM.DLL)(-pSTM32F103RB)
  OPTDBG 48118,1,()()()()()()()()()() (BIN\UL2CM3.DLL)()()()
 FLASH1 { 9,0,0,0,1,0,0,0,1,16,0,0,0,0,0,0,0,0,0,0 }
 FLASH2 (BIN\UL2CM3.DLL)
 FLASH3 ("" ())
 FLASH4 ()
EndOpt

Options 2,0,0  // Target 'Reel'
 Device (STM32F103RB)
 Vendor (STMicroelectronics)
 Cpu (IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3"))
 FlashUt ()
 StupF ("STARTUP\ST\STM32F10x.s" ("STM32 Startup Code"))
 FlashDR (UL2CM3(-O14 -S0 -C0 -N00("ARM Cortex-M3") -D00(1BA00477) -L00(4) -FO7 -FD20000000 -FC800 -FN1 -FF0STM32F10x_128 -FS08000000 -FL020000))
 DevID (4231)
 Rgf (stm32f10x_lib.h)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg (ÿST\STM32F10x\)
 OrgReg (ÿST\STM32F10x\)
 TgStat=16
 OutDir (.\)
 OutName (Projet_GCC)
 GenApp=1
 GenLib=0
 GenHex=0
 Debug=1
 Browse=1
 LstDir (.\)
 HexSel=1
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 CrunUsr 0 0 <>
 CrunUsr 1 0 <>
 SVCSID <>
 GLFLAGS=1790
 GCPUTYP ("Cortex-M3")
 TFlagsA { 0,12,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCMARM { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCMARAM { 0,0,0,0,32,0,80,0,0 }
 OCMAROM { 1,0,0,0,8,0,0,2,0 }
 OCMXRAM { 0,0,0,0,0,0,0,0,0 }
 OCMIRAM2 { 0,0,0,0,0,0,0,0,0 }
 OCMIROM2 { 0,0,0,0,0,0,0,0,0 }
 ACCFLG { 65,0,32,16,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ACMISC ()
 ACDEFN ()
 ACUDEF ()
 ACINCD ()
 AASFLG { 4,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 AAMISC ()
 AADEFN ()
 AAUDEF ()
 AAINCD ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 ALDFLAG { 3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ALDTADR ()
 ALDDADR ()
 ALDBSSR ()
 ALDICLB ()
 ALDICDR ()
 ALDMISC ()
 ALDSCAT (..\..\system\Linker_Script_GCC.ld)
  OPTDL (SARMCM3.DLL)()(DARMSTM.DLL)(-pSTM32F103RB)(SARMCM3.DLL)()(TARMSTM.DLL)(-pSTM32F103RB)
  OPTDBG 49150,1,()()()()()()()()()() (BIN\UL2CM3.DLL)()()()
 FLASH1 { 9,0,0,0,0,0,0,0,255,255,255,255,0,0,0,0,0,0,0,0 }
 FLASH2 (BIN\UL2CM3.DLL)
 FLASH3 ("" ())
 FLASH4 ()
EndOpt

Options 3,0,0  // Target 'lkjh'
 Device (STM32F103RB)
 Vendor (STMicroelectronics)
 Cpu (IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3"))
 FlashUt ()
 StupF ("STARTUP\ST\STM32F10x.s" ("STM32 Startup Code"))
 FlashDR (UL2CM3(-O14 -S0 -C0 -N00("ARM Cortex-M3") -D00(1BA00477) -L00(4) -FO7 -FD20000000 -FC800 -FN1 -FF0STM32F10x_128 -FS08000000 -FL020000))
 DevID (4231)
 Rgf (stm32f10x_lib.h)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg ()
 OrgReg (ST\STM32F10x\)
 TgStat=16
 OutDir (.\)
 OutName (test_preempt_full_schedule)
 GenApp=1
 GenLib=0
 GenHex=0
 Debug=0
 Browse=0
 LstDir (.\)
 HexSel=1
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 CrunUsr 0 0 <>
 CrunUsr 1 0 <>
 SVCSID <>
 GLFLAGS=1790
 GCPUTYP ("Cortex-M3")
 TFlagsA { 0,12,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCMARM { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCMARAM { 0,0,0,0,32,0,80,0,0 }
 OCMAROM { 1,0,0,0,8,0,0,2,0 }
 OCMXRAM { 0,0,0,0,0,0,0,0,0 }
 OCMIRAM2 { 0,0,0,0,0,0,0,0,0 }
 OCMIROM2 { 0,0,0,0,0,0,0,0,0 }
 ACCFLG { 65,0,32,16,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ACMISC ()
 ACDEFN ()
 ACUDEF ()
 ACINCD (..\..\trampoline\com;..\..\trampoline\os;..\..\trampoline\debug;..\..\trampoline\machines\cortex-m3;..\..\lib_user;.\test_preempt_full_schedule)
 AASFLG { 4,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 AAMISC ()
 AADEFN ()
 AAUDEF ()
 AAINCD ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 ALDFLAG { 3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ALDTADR ()
 ALDDADR ()
 ALDBSSR ()
 ALDICLB ()
 ALDICDR ()
 ALDMISC ()
 ALDSCAT (..\..\system\Linker_Script_GCC.ld)
  OPTDL (SARMCM3.DLL)()(DARMSTM.DLL)(-pSTM32F103RB)(SARMCM3.DLL)()(TARMSTM.DLL)(-pSTM32F103RB)
  OPTDBG 48126,1,()()()()()()()()()() (BIN\UL2CM3.DLL)()()()
 FLASH1 { 1,0,0,0,1,0,0,0,1,16,0,0,0,0,0,0,0,0,0,0 }
 FLASH2 (BIN\UL2CM3.DLL)
 FLASH3 ("" ())
 FLASH4 ()
EndOpt

