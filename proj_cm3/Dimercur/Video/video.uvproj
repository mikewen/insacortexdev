# Keil uVision project video.uvproj, settings and files
target Simu (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: video
  AfterMake: "C:\Program Files\CodeSourcery\Sourcery G++ Lite\bin\arm-none-eabi-size.exe" objs\*.elf
  group Systeme
    ../../system/: STM32F10x_GCC.s Startup_GCC.s
    ../../lib_cm3/: stm_clock.c stm_usartx.c
  group Appli
    ./: video.c
  group fonts
    ./font/: font8.c font9.c font14.c font16.c fontcour.c fontgl.c fontline.c fontx13.c fontx13b.c fontx16.c
