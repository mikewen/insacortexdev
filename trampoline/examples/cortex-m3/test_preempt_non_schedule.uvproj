# Keil uVision project test_preempt_non_schedule.uvproj, settings and files
target Simulé (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Projet_GCC
  group Systeme
    ./: STM32_Init.c STM32F10x.s
  group os
    ../../os/: tpl_os_action.c tpl_os_alarm_kernel.c tpl_os_alarm.c tpl_os_error.c tpl_os_event.c tpl_os_it_kernel.c tpl_os_it.c tpl_os_kernel.c tpl_os_rez_kernel.c tpl_os_rez.c tpl_os_task.c tpl_os.c tpl_os_timeobj_kernel.c tpl_os_dispatch_table.c tpl_os_event_kernel.c tpl_os_task_kernel.c
  group os_machine
    ../../machines/cortex-m3/: tpl_machine_cm3.c
  group Appli
    ./: test_preempt_full_schedule_main.c
    ./test_preempt_non_schedule/: tpl_os_generated_configuration.c
  group Include
    ../../system/: STM32_Init.h STM32_Reg.h
  group templates
    ./App/: archi_appli.oil
    ./templates/c166/: isr_specific.tpl counter_list_specific.tpl counter_specific.tpl each_isr_specific.tpl each_task_specific.tpl
target Reel (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Projet_GCC
