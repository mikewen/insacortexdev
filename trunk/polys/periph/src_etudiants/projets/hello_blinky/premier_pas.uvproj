# Keil uVision project premier_pas.uvproj, settings and files
target simulateur (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: premier_pas
  group sys
    ../../sys/: STM32F10x_GCC.s Startup_GCC.s Linker_Script_GCC.ld
  group pilotes
    ../../pilotes/: stm_clock.c
    ./: stm_clock_config.h
  group appli
    ./: main.c
