# Keil uVision project test_regs_and_clock.uvproj, settings and files
target Simu (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test_regs_and_clock
  group Startup
    ../../../system/: STM32F10x_GCC.s Startup_GCC.s
  group Apps
    ./: main.c syscalls.c
  group Drivers
    ../../../lib_cm3/: stm_clock.c stm_usartx_v2.c
