# Keil uVision project exo_TD2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: testt
  c flags: Optim=1
  asm define: Registre = 2
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x500
  memory RVCT2: ROM 0x500000 size 0x1000
  memory RVCT6: RAM 0x20000000 size 0x1000
  memory RVCT7: RAM 0x30000 size 0x500
  group Source Group 1
    ./: STM32F10x.s test.asm
