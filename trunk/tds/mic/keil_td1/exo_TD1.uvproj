# Keil uVision project exo_TD1.uvproj, settings and files
target simu_c (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: testt
  c flags: Optim=3 wLevel=2
  asm define: Registre = 2
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x500
  memory RVCT2: ROM 0x500000 size 0x1000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x20000000 size 0x1000
  memory RVCT7: RAM 0x30000 size 0x500
  group Source
    ./: STM32F10x.s main.c quick.asm
target quick_asm (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: testt
  c flags: Optim=4 wLevel=2
  asm define: Registre = 2
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x500
  memory RVCT2: ROM 0x500000 size 0x1000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x20000000 size 0x1000
  memory RVCT7: RAM 0x30000 size 0x500
