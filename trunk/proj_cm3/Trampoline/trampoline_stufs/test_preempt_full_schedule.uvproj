# Keil uVision project test_preempt_full_schedule.uvproj, settings and files
target Simulé (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test_preempt_full_schedule
  group Systeme
    ./: STM32_Init.c STM32F10x_GCC.s Startup_GCC.s
  group os
    ../../../trampoline/os/: tpl_os.c tpl_os_action.c tpl_os_alarm.c tpl_os_alarm_kernel.c tpl_os_dispatch_table.c tpl_os_error.c tpl_os_event.c tpl_os_event_kernel.c tpl_os_it.c tpl_os_it_kernel.c tpl_os_kernel.c tpl_os_rez.c tpl_os_rez_kernel.c tpl_os_task.c tpl_os_task_kernel.c tpl_os_timeobj_kernel.c
  group os_machines
    ../../../trampoline/machines/cortex-m3/: tpl_machine_cm3.c
  group os_com
    ../../../trampoline/com/: tpl_com_queue.c tpl_com_app_copy.c tpl_com_errorhook.c tpl_com_external_com.c tpl_com_filtering.c tpl_com_filters.c tpl_com_internal_com.c tpl_com_message_management.c tpl_com_notification.c
  group os_debug
    ../../../trampoline/debug/: tpl_debug.c
  group Lib
    ../../../lib_user/: uart.c LCD_4bit.c lib_trajectoire_2009a.c led.c
  group Appli
    ./test_preempt_full_schedule/: tpl_os_generated_configuration.c
    ./: test_preempt_full_schedule_main.c
  group Include
    ../../../lib_user/: lib_trajectoire_2009a.h lib_autom_2008a.h LCD.h uart.h
target Reel (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Projet_GCC
