# Keil uVision project toto.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: toto
  AfterMake: "C:\Program Files\CodeSourcery\bin\arm-none-eabi-size.exe" *.elf
  group Source Group 1
    ../../system/: Startup_GCC.s STM32F10x_GCC.s
    ./: main.c
  group New Group
    ../../lib_cm3/: lib_usartx.c stm_clock.c lib_usartx.h stm3_stub.c
    ./: stm_clock_config.h
