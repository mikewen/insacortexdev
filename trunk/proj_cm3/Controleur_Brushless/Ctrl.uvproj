# Keil uVision project Ctrl.uvproj, settings and files
target Simu (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: controleur
  AfterMake: "C:\Program Files\CodeSourcery\Sourcery G++ Lite\bin\arm-none-eabi-size.exe" ./Objs/*.elf
  group System
    ../../system/: STM32F10x_GCC.s Startup_GCC.s
  group Drivers
    ../../lib_cm3/: stm_clock.c stm_usartx.c LCD_4bit.c
    ./: adc.c
  group Interface
    ./Interface/: interface.c interface_uart.c
  group Lib
    ./: syscalls.c
  group Application
    ./: hacheur.c capteur.c init.c controle.c asservissement.c
  group Infos
    ./: infos.txt
  group Simulation
    ./: Brushless_1.ini
target Reel (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: controleur
  AfterMake: as above
