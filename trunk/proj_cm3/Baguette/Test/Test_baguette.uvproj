# Keil uVision project Test_baguette.uvproj, settings and files
target Reel (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Test_Baguette
  c flags: Optim=1
  c include: ..\..\..\lib_user;..\..\..\lib_cm3;..\Test;..\..\..\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ./: STM32F10x.s
  group Apps
    ./: main.c font8.c
  group Lib
    ../../../lib_cm3/: stm_clock.c LCD_4bit.c stm_usartx.c
  group objs
    ../objs_lib_baguette/: lib_baguette.o
target Simu (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Test_Baguette
  c flags: Optim=1
  c include: ..\..\..\lib_cm3;..\..\..\lib_user;..\Test;..\..\..\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
