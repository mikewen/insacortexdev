# Keil uVision project adc_dma.uvproj, settings and files
target simulateur (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: adc_dma
  group system
    ../../../system/: Startup_GCC.s STM32F10x_GCC.s
  group lib
    ./: syscalls_usb_cdc.c
    ../../../lib_cm3/: stm_clock.c stm_timx.c cm3_traps.c stm_system.c stm_usartx.c stm_adc.c
  group appli
    ./: main.c
  group configs
    ./configs/: stm_usartx_config.h cm3_traps_config.h stm_adc_config.h stm_clock_config.h stm_timx_config.h
    ../../../lib_cm3/USB/specifique/CDC/conf/: hw_config.h platform_config.h usb_conf.h
  group USB_gen
    ../../../lib_cm3/USB/generique/: usb_sil.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group USB_CDC
    ../../../lib_cm3/USB/specifique/CDC/: usb_pwr.c usb_cdc.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c
