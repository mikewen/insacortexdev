# Keil uVision project c.uvproj, settings and files
target libc (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: c +hex
  AfterMake: "C:\Program Files\CodeSourcery\Sourcery G++ Lite\bin\arm-none-eabi-size.exe" ../lib/*.a
  AfterMake: "C:\Program Files\CodeSourcery\Sourcery G++ Lite\bin\arm-none-eabi-size.exe" ../lib/*.elf
  group stdio
    ../stdio/: asiprintf.c asniprintf.c asnprintf.c asprintf.c clearerr.c diprintf.c dprintf.c fclose.c fcloseall.c fdopen.c feof.c ferror.c fflush.c fgetc.c fgetpos.c fgets.c fgetwc.c fgetws.c fileno.c findfp.c fiprintf.c fiscanf.c flags.c fmemopen.c fopen.c fopencookie.c fprintf.c fpurge.c fputc.c fputs.c fputwc.c fputws.c fread.c freopen.c fscanf.c fseek.c fseeko.c fsetpos.c ftell.c ftello.c funopen.c fvwrite.c fwalk.c fwide.c fwprintf.c fwrite.c fwscanf.c getc.c getc_u.c getchar.c getchar_u.c getdelim.c getline.c gets.c getw.c getwc.c getwchar.c iprintf.c iscanf.c makebuf.c mktemp.c open_memstream.c perror.c printf.c putc.c putc_u.c putchar.c putchar_u.c puts.c putw.c putwc.c putwchar.c refill.c remove.c rename.c rewind.c rget.c scanf.c sccl.c setbuf.c setbuffer.c setlinebuf.c setvbuf.c siprintf.c siscanf.c sniprintf.c snprintf.c sprintf.c sscanf.c stdio.c swprintf.c swscanf.c tmpfile.c tmpnam.c ungetc.c ungetwc.c vasiprintf.c vasniprintf.c vasnprintf.c vasprintf.c vdiprintf.c vdprintf.c vfprintf.c vfscanf.c vfwprintf.c vfwscanf.c viprintf.c viscanf.c vprintf.c vscanf.c vsiprintf.c vsiscanf.c vsniprintf.c vsnprintf.c vsprintf.c vsscanf.c vswprintf.c vswscanf.c vwprintf.c vwscanf.c wbuf.c wprintf.c wscanf.c wsetup.c
  group stdlib
    ../stdlib/: __adjust.c __atexit.c __call_atexit.c __exp10.c __ten_mu.c _Exit.c a64l.c abort.c abs.c assert.c atexit.c atof.c atoff.c atoi.c atol.c atoll.c btowc.c calloc.c cxa_atexit.c cxa_finalize.c div.c drand48.c dtoa.c dtoastub.c ecvtbuf.c efgcvt.c environ.c envlock.c eprintf.c erand48.c exit.c gdtoa-gethex.c gdtoa-hexnan.c getenv.c getenv_r.c getopt.c getsubopt.c jrand48.c l64a.c labs.c lcong48.c ldiv.c ldtoa.c llabs.c lldiv.c lrand48.c malign.c malloc.c mallocr.c mblen.c mblen_r.c mbrlen.c mbrtowc.c mbsinit.c mbsnrtowcs.c mbsrtowcs.c mbstowcs.c mbstowcs_r.c mbtowc.c mbtowc_r.c mlock.c mprec.c mrand48.c msize.c mstats.c mtrim.c nrand48.c on_exit.c putenv.c putenv_r.c rand48.c rand.c rand_r.c realloc.c reallocf.c sb_charsets.c seed48.c setenv.c setenv_r.c srand48.c strtod.c strtol.c strtold.c strtoll.c strtoll_r.c strtoul.c strtoull.c strtoull_r.c system.c valloc.c wcrtomb.c wcsnrtombs.c wcsrtombs.c wcstod.c wcstol.c wcstold.c wcstoll.c wcstoll_r.c wcstombs.c wcstombs_r.c wcstoul.c wcstoull.c wcstoull_r.c wctob.c wctomb.c wctomb_r.c
  group include
    ../include/: _ansi.h _syslist.h alloca.h ar.h argz.h assert.h ctype.h dirent.h envlock.h envz.h errno.h fastmath.h fcntl.h fnmatch.h getopt.h glob.h grp.h iconv.h ieeefp.h inttypes.h langinfo.h libgen.h limits.h locale.h malloc.h math.h newlib.h paths.h process.h pthread.h pwd.h reent.h regdef.h regex.h sched.h search.h setjmp.h signal.h stdint.h stdio.h stdlib.h string.h tar.h termios.h time.h unctrl.h unistd.h utime.h utmp.h wchar.h wctype.h wordexp.h
  group string
    ../string/: bcmp.c bcopy.c bzero.c index.c memccpy.c memchr.c memcmp.c memcpy.c memmem.c memmove.c mempcpy.c memset.c rindex.c stpcpy.c stpncpy.c strcasecmp.c strcasestr.c strcat.c strchr.c strcmp.c strcoll.c strcpy.c strcspn.c strdup.c strdup_r.c strerror.c strerror_r.c strlcat.c strlcpy.c strlen.c strlwr.c strncasecmp.c strncat.c strncmp.c strncpy.c strndup.c strndup_r.c strnlen.c strpbrk.c strrchr.c strsep.c strspn.c strstr.c strtok.c strtok_r.c strupr.c strxfrm.c swab.c u_strerr.c wcpcpy.c wcpncpy.c wcscasecmp.c wcscat.c wcschr.c wcscmp.c wcscoll.c wcscpy.c wcscspn.c wcsdup.c wcslcat.c wcslcpy.c wcslen.c wcsncasecmp.c wcsncat.c wcsncmp.c wcsncpy.c wcsnlen.c wcspbrk.c wcsrchr.c wcsspn.c wcsstr.c wcstok.c wcswidth.c wcsxfrm.c wcwidth.c wmemchr.c wmemcmp.c wmemcpy.c wmemmove.c wmemset.c
  group application
    ./: test.c Startup_GCC.s STM32F10x_GCC.s Linker_Script_GCC.ld stm3_stub.c autre_stub.c syscalls.c mul_stub.c
  group ctype
    ../ctype/: ctype_.c isalnum.c isalpha.c isascii.c isblank.c iscntrl.c isdigit.c islower.c isprint.c ispunct.c isspace.c isupper.c iswalnum.c iswalpha.c iswblank.c iswcntrl.c iswctype.c iswdigit.c iswgraph.c iswlower.c iswprint.c iswpunct.c iswspace.c iswupper.c iswxdigit.c isxdigit.c jp2uc.c toascii.c tolower.c toupper.c towctrans.c towlower.c towupper.c wctrans.c wctype.c
  group reent
    ../reent/: closer.c execr.c fcntlr.c fstat64r.c fstatr.c getreent.c gettimeofdayr.c impure.c isattyr.c linkr.c lseek64r.c lseekr.c mkdirr.c open64r.c openr.c readr.c reent.c renamer.c sbrkr.c signalr.c signgam.c stat64r.c statr.c timesr.c unlinkr.c writer.c
  group errno
    ../errno/: errno.c
  group locale
    ../locale/: fix_grouping.c ldpart.c lmessages.c lmonetary.c lnumeric.c locale.c nl_langinfo.c timelocal.c
  group signal
    ../signal/: raise.c signal.c
  group misc
    ../misc/: __dprintf.c ffs.c init.c unctrl.c
  group times
    ../time/: asctime.c asctime_r.c clock.c ctime.c ctime_r.c difftime.c gettzinfo.c gmtime.c gmtime_r.c lcltime.c lcltime_r.c mktime.c mktm_r.c strftime.c strptime.c time.c tzlock.c tzset.c tzset_r.c tzvars.c wcsftime.c
  group syscalls
    ../syscalls/: sysclose.c sysexecve.c sysfcntl.c sysfork.c sysfstat.c sysgetpid.c sysgettod.c sysisatty.c syskill.c syslink.c syslseek.c sysopen.c sysread.c syssbrk.c sysstat.c systimes.c sysunlink.c syswait.c syswrite.c
